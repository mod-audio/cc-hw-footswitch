File: MOD_Foot_Prototype1/MOD_Foot_Prototype1.kicad_pcb (KiCad board)
At the start: 2 copper layers, 248.9 x 74.2 mm, 96 parts, among them CN1 CONN_PANNEL_2X2, CN2 CONN_PANNEL_2X2, J1 RJ45_CHAIN_MAIN, J2 RJ45_CHAIN_EXTENSION, P1 HEADER_5X2, P2 HEADER_5X2, Q1 MMBT3904, Q2 MMBT3906, Q3 MMBT3904, U1 LPC111X_LQFP48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

Commit message: tweaking the pcb layout to avoid islands without copper in the ground plane.
Routing:
- net Net-(C5-Pad1): track 49.0 -> 46.0 mm
- net RS485_RX+: track 51.3 -> 49.9 mm
- net Net-(Q2-Pad1): track 21.3 -> 22.1 mm
- net UC_TX_CHAIN: track 25.1 -> 25.7 mm
