File: hw-design/board/io.sch (KiCad schematic (older format))
At the start: 33 parts, among them P4 FOOT, P5 FOOT, P6 FOOT, P7 FOOT, SW2 SP3T, U5 PCA9685

Commit message: sch: kicad libray updated + missing footprints added
Parts:
- D5, D6, D7, D8: footprint LEDs:LED_RGB_PLLC-6 -> LEDs:LED-RGB_PLLC-6
Other:
- moved on the sheet: C17, C18, C19, C20, D5, D6, D7, D8

Commit message: sch: channel selector switch is no longer used
Parts:
- removed R25, R26, R27: 10k, Resistors_SMD:R_0603, symbol R
- removed SW2: SP3T, local-footprints:OS103011MA7QP1, symbol SP3T
- renumbered R28 to R25, R29 to R26, R30 to R27, R31 to R28, R32 to R29, R33 to R30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
Other:
- note removed: "CHANNEL SELECTOR"
- moved on the sheet: C17, C18, C19, C20, D5, D6, D7, D8, P4, P5, P6, P7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

Commit message: sch: schematic files reorganized, new sheets for usb and rear board
Parts:
- renumbered C17 to C14, C18 to C15, C19 to C16, C20 to C17, D5 to D4, D6 to D5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

Commit message: connecting foot leds directly to cpu
Parts:
- removed C14, C15, C16, C17: 100nF X7R, Capacitors_SMD:C_0603, symbol C
- removed U5: PCA9685, Housings_SSOP:TSSOP-28_4.4x9.7mm_Pitch0.65mm, symbol PCA9685
Connections:
- net LED_B1: now reaches R11.1
- net LED_R1: now reaches R12.1
- net LED_G1: now reaches R13.1
- net LED_B2: now reaches R14.1
- net LED_R2: now reaches R15.1
- net LED_G2: now reaches R16.1
- net LED_B3: now reaches R17.1
- net LED_R3: now reaches R18.1
- net LED_G3: now reaches R19.1
- net LED_B4: now reaches R20.1
- net LED_R4: now reaches R21.1
- net LED_G4: now reaches R22.1
- no-connect marks 4 -> 0
Other:
- moved on the sheet: D4, D5, D6, D7, P5, R11, R12, R13, R14, R15, R16, R17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
