# Repository mod-audio/cc-hw-footswitch (continued)

## KiCad design MOD_Foot_Prototype1/MOD_Foot_Prototype1.kicad_pcb (continued)

Parts:
C9, C12, C13: 100nF_X7R; SM0603
C10, C11: 18pF_NP0; SM0603
CN1, CN2: CONN_PANNEL_2X2; CONN_PANNEL
P1, P2: HEADER_5X2; PIN_ARRAY_5x2
R32, R33, R46, R47: 10k; SM0603
R39, R42, R43, R45: 0R; SM0805
R40, R41: 100R; SM0603
U1: LPC111X_LQFP48; LQFP48
X1: 10MHz; HC_49US

Connections:
+3.3V: C12.1, C13.1, R32.1, R33.1, R39.1, R46.1, R47.1, U1.8 (VDD), U1.44 (VDD); also elsewhere on the board
+5V: P1.3, P1.4; also elsewhere on the board
FOOT_1: U1.37 (PIO3_1/~DSR); also elsewhere on the board
FOOT_2: U1.36 (PIO3_0/~DTR); also elsewhere on the board
FOOT_3: U1.32 (R/PIO0_11/AD0/CT32B0_MAT3); also elsewhere on the board
FOOT_4: U1.27 (PIO0_8/MISO0/CT16B0_MAT0); also elsewhere on the board
LED1_B: U1.40 (PIO1_4/AD5/CT32B1_MAT3/WAKEUP); also elsewhere on the board
LED1_G: U1.43 (PIO3_2/~DCD); also elsewhere on the board
LED1_R: U1.42 (PIO1_11/AD7); also elsewhere on the board
LED2_B: U1.33 (R/PIO1_0/AD1/CT32B1_CAP0); also elsewhere on the board
LED2_G: U1.35 (R/PIO1_2/AD3/CT32B1_MAT1); also elsewhere on the board
LED2_R: U1.34 (R/PIO1_1/AD2/CT32B1_MAT0); also elsewhere on the board
LED3_B: U1.28 (PIO0_9/MOSI0/CT16B0_MAT1); also elsewhere on the board
LED3_G: U1.31 (PIO2_11/SCK0); also elsewhere on the board
LED3_R: U1.30 (PIO1_10/AD6/CT16B1_MAT1); also elsewhere on the board
LED4_B: U1.23 (PIO0_7/~CTS); also elsewhere on the board
LED4_G: U1.25 (PIO2_10); also elsewhere on the board
LED4_R: U1.24 (PIO2_9); also elsewhere on the board
LED5: U1.48 (PIO3_3/~RI); also elsewhere on the board
unnamed: C10.2, U1.6 (XTALIN), X1.2
unnamed: C11.2, U1.7 (XTALOUT), X1.1
unnamed: P2.1, R39.2
unnamed: P2.2, R40.2
unnamed: P2.4, R41.2
unnamed: R32.2, U1.4 (PIO0_1/CLKOUT/CT32B0_MAT2)
RESET: C9.1, P2.10, R33.2, U1.3 (~RESET~/PIO0_0)
RX_CHAIN: P1.5, R42.1; also elsewhere on the board
SWDCLK: R41.1, U1.29 (SWCLK/PIO0_10/SCK0/CT16B0_MAT2)
SWDIO: R40.1, U1.39 (SWDIO/PIO1_3/AD4/CT32B1_MAT2)
TX_CHAIN: P1.7, R43.1; also elsewhere on the board
TX_CHAIN_EN: P1.9, R45.1; also elsewhere on the board
UC_LCD0: U1.2 (PIO2_0/~DTR~/SSEL1); also elsewhere on the board
UC_LCD1: U1.13 (PIO2_1/~DSR~/SCK1); also elsewhere on the board
UC_LCD2: U1.26 (PIO2_2/~DCD~/MISO1); also elsewhere on the board
UC_LCD3: U1.38 (PIO2_3/~RI~/MOSI1); also elsewhere on the board
UC_LCD4: U1.19 (PIO2_4); also elsewhere on the board
UC_LCD5: U1.20 (PIO2_5); also elsewhere on the board
UC_LCD6: U1.1 (PIO2_6); also elsewhere on the board
UC_LCD7: U1.11 (PIO2_7); also elsewhere on the board
UC_LCD_BACK: U1.12 (PIO2_8); also elsewhere on the board
UC_LCD_DIR: U1.14 (PIO0_3); also elsewhere on the board
UC_LCD_E: R47.2, U1.15 (PIO0_4/SCL); also elsewhere on the board
UC_LCD_RS: U1.17 (PIO1_9/CT16B1_MAT0); also elsewhere on the board
UC_LCD_RW: R46.2, U1.16 (PIO0_5/SDA); also elsewhere on the board
UC_RX_CHAIN: P1.6, R42.2, U1.46 (PIO1_6/RXD/CT32B0_MAT0)
UC_TX_CHAIN: P1.8, R43.2, U1.47 (PIO1_7/TXD/CT32B0_MAT1)
UC_TX_CHAIN_EN: P1.10, R45.2, U1.45 (PIO1_5/~RTS~/CT32B0_CAP0)

Parts:
FOOT1, FOOT2, FOOT3, FOOT4: HEADER_2X1_180; PIN_ARRAY_2X1
LED1, LED2, LED3, LED4: LED_RGB; LED_CLRTB_GFSF_1
R7, R8, R9, R10: 10k; SM0603
R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25: 1k; SM0603

Connections:
+3.3V: LED1.4 (KB), LED1.5 (KG), LED1.6 (KR), LED2.4 (KB), LED2.5 (KG), LED2.6 (KR), LED3.4 (KB), LED3.5 (KG), LED3.6 (KR), LED4.4 (KB), LED4.5 (KG), LED4.6 (KR), R7.1, R8.1, R9.1, R10.1; also elsewhere on the board
FOOT_1: FOOT1.2 (PM), R7.2; also elsewhere on the board
FOOT_2: FOOT2.2 (PM), R8.2; also elsewhere on the board
FOOT_3: FOOT3.2 (PM), R9.2; also elsewhere on the board
FOOT_4: FOOT4.2 (PM), R10.2; also elsewhere on the board
LED1_B: R14.2; also elsewhere on the board
LED1_G: R16.2; also elsewhere on the board
LED1_R: R15.2; also elsewhere on the board
LED2_B: R17.1; also elsewhere on the board
LED2_G: R19.1; also elsewhere on the board
LED2_R: R18.1; also elsewhere on the board
LED3_B: R20.1; also elsewhere on the board
LED3_G: R22.1; also elsewhere on the board
LED3_R: R21.1; also elsewhere on the board
LED4_B: R23.1; also elsewhere on the board
LED4_G: R25.1; also elsewhere on the board
LED4_R: R24.1; also elsewhere on the board
unnamed: LED1.1 (AR), R14.1
unnamed: LED1.2 (AG), R15.1
unnamed: LED1.3 (AB), R16.1
unnamed: LED2.1 (AR), R17.2
unnamed: LED2.2 (AG), R18.2
unnamed: LED2.3 (AB), R19.2
unnamed: LED3.1 (AR), R20.2
unnamed: LED3.2 (AG), R21.2
unnamed: LED3.3 (AB), R22.2
unnamed: LED4.1 (AR), R23.2
unnamed: LED4.2 (AG), R24.2
unnamed: LED4.3 (AB), R25.2

Parts:
C1, C3, C6: 100uF; CAP_RAD_5MM
C2, C4, C7: 100nF_X7R; SM0603
D1: CGRA4007-G; DO-214AC(SMA)
R26, R38: 0R; SM0805
RT1: PTC_FUSE_500mA; SM2920
RT2: PTC_FUSE_500mA; SM1210
TP1, TP2, TP3: CONN_1; SIL-1
U2: MC7805; DPAK(369C)
U3: NCP1117DT33G; DPAK(369C)

Connections:
+3.3V: R26.2; also elsewhere on the board
+5V: R38.2; also elsewhere on the board
+9V: C1.1, C2.1, RT1.2, RT2.2, U2.1 (VIN)
unnamed: C3.1, C4.1, R38.1, TP2.1, U2.3 (VOUT), U3.3 (VIN)
unnamed: C6.1, C7.1, R26.1, TP1.1, U3.2 (VOUT)
unnamed: D1.2 (K), RT1.1, RT2.1
VCC: D1.1 (A); also elsewhere on the board

Parts:
C14, C15, C17: 100nF_X7R; SM0603
C16: 100uF; CAP_RAD_5MM
LCD1: AGM-2004A-204; LCD-AGM-2004A-204
Q3: MMBT3904; SOT23
R34: 3k; SM0805
R35: 330R; SM0805
R36: 1k; SM0603
R37: 0R; SM0805
U5, U6: 74HC245; TSSOP20

Connections:
+5V: C14.2, C15.2, C16.1, C17.1, LCD1.2 (VDD), LCD1.15 (LEDA), R34.2, U5.20 (VCC), U6.1 (DIR), U6.20 (VCC); also elsewhere on the board
LCD0: LCD1.7 (DB0), U5.18 (B1)
LCD1: LCD1.8 (DB1), U5.17 (B2)
LCD2: LCD1.9 (DB2), U5.16 (B3)
LCD3: LCD1.10 (DB3), U5.15 (B4)
LCD4: LCD1.11 (DB4), U5.14 (B5)
LCD5: LCD1.12 (DB5), U5.13 (B6)
LCD6: LCD1.13 (DB6), U5.12 (B7)
LCD7: LCD1.14 (DB7), U5.11 (B8)
LCD_E: LCD1.6 (E), U6.11 (B8)
LCD_RS: LCD1.4 (RS), U6.13 (B6)
LCD_RW: LCD1.5 (R/W), U6.12 (B7)
unnamed: LCD1.3 (VO), R34.1, R35.2
unnamed: LCD1.16 (LEDK), R37.2
unnamed: Q3.3 (C), R37.1
UC_LCD0: U5.2 (A1); also elsewhere on the board
UC_LCD1: U5.3 (A2); also elsewhere on the board
UC_LCD2: U5.4 (A3); also elsewhere on the board
UC_LCD3: U5.5 (A4); also elsewhere on the board
UC_LCD4: U5.6 (A5); also elsewhere on the board
UC_LCD5: U5.7 (A6); also elsewhere on the board
UC_LCD6: U5.8 (A7); also elsewhere on the board
UC_LCD7: U5.9 (A8); also elsewhere on the board
UC_LCD_BACK: R36.1; also elsewhere on the board
UC_LCD_DIR: U5.1 (DIR); also elsewhere on the board
UC_LCD_E: U6.9 (A8); also elsewhere on the board
UC_LCD_RS: U6.7 (A6); also elsewhere on the board
UC_LCD_RW: U6.8 (A7); also elsewhere on the board

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
Board: 2 copper layers, 248.9 x 74.2 mm, 98 parts (5 on the bottom side), 98 nets.

## Commit log

2014-05-15 Initial commit of MOD Foot. MOD_Foot_Prototype1.
2014-06-03 BOM for ITEAD quotes.
2014-06-04 Solved schematic diagram of rs422 protection zener diodes.
2014-06-16 Created BOM with ITEAD template.
2014-12-01 Adding a readme (also fixes issue #3: Declaring a CC By SA License)
2014-12-01 Adding a README reference to the repository wuth the firmware source code. (fix issue #2)
2014-12-02 fix issue #14: Broken component/footprint map file This commit makes the mod-arduino-shield a dependency. We must still move the footprint library to a single repository and declare it properly as a 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
2014-12-02 removing local footprint library and adding a submodule to use the footprint library available at the https://github.com/portalmod/mod-kicad-footprints repository.
2014-12-02 update footprint lib references in the kicad_pcb file as well... (and a relative path in the netlist file)
2014-12-03 updating README (with submodule checkout instructions)
2014-12-03 fixing markdown syntax
2014-12-03 further tweak the instructions
2014-12-05 grounding the mechanical connectors (and regenerating Gerber files)
2014-12-05 removing redundant Gerber files (Gerber/ITEAD/ subdir)
2014-12-05 Bringing back the positioning of references and values that were messed up with in the recent refactoring.
2014-12-08 rearrange R38 and C3 components (fix issue #7)
2014-12-08 fixing LED labels in the schematics (they are output signals, not inputs).
2014-12-08 wip issue #13 - changing schematics We're freeing the AD5/PIO1_4 and AD7/PIO1_11 pins. LED1_B and LED1_R, which used these, will now use PIO3_5 and PIO3_4, respectively.
2014-12-08 updating pcb traces (fixes issue #13: ADC availability)
2014-12-09 wip issue #11: protect the U4 IC when the board is being debugged - made the changes in the schematics
2014-12-09 fix issue #11: protect the U4 IC when the board is being debugged Updated PCB traces and regenerated Gerbers.
2014-12-09 fixed issue #9 by adding an SM1210 footprint for a second fuse. It's up to us to decide which kind of fuse to solder in the board, but the PCB has got both footprints.
2014-12-09 sch: created one sheet for each part of the circuit
2014-12-09 wip issue #4: Added MAX13450E part to project library
2014-12-09 fix issue #8: MMBT3904 pinout fixed + Added MMBT3906 PNP transistor
2014-12-09 fix issue #4: sch: full duplex control chain circuit done
2014-12-09 sch: applying page settings to all sheets
2014-12-10 sch: ERC passing
2014-12-10 yet about issue #11: sch: pins 9 and 10 are being connected with 0R resitor
2014-12-10 * fix wrong control-chain signal names * annotate new resistors added to the sch * rearrange sch drawing around header P1
2014-12-10 Fixing schematics references numbering. Also regenerated .net and .cmp files.
2014-12-10 fixing the footprint for the MAX1345 chip.
2014-12-10 fix issue #16: fix footprint of 1/2w resistors (The 1/2 W resistores should use the footprint SM1210.)
2014-12-10 wip - retracing PCB to accomodate schematic changes from previous recent commits.
2014-12-10 fix issues #4 and #11 - traced all pcb signals and regenerated Gerber files.
2014-12-10 changing the position of the C5 capacitor to make it fit (it was too tight to place it between the RJ45 connectors)
2014-12-11 tweaking the pcb layout to avoid islands without copper in the ground plane.
2014-12-12 fix issue #1: Add "CC by-SA" license logo to the PCB silk layer
2014-12-16 add pull up resistors (to 3V3) to the LCD ENABLE and RW signals (wip issue #10)
2014-12-16 fix issue #10: updating the PCB layout with the added pull up resistors for LCD ENABLE and RW signals
2014-12-17 Adding 3.3V reference voltage Vl to MAX13450E. Also changing the pull up voltage from 5V to 3.3V on the R0 and TERM100 signals.
2014-12-17 Modifying the control chain RTERM_CHAIN circuit to generate a 3.3V logic signal. (instead of 5 volts)
2014-12-17 updating pcb layout
2014-12-18 plotting the schematics to a PDF to be kept in the Docs directory (we should always update this PDF when we make changes to the schematics).
2015-01-06 project renamed
2015-01-06 updating MAX13450E symbol
2015-01-07 fixing name of the standard RS-485 -> RS-422
2015-01-07 using RJ45 leds to indicate cable connection status instead of power status
2015-01-15 exporting schematics PDF
2015-01-15 wip: breaking pcbs apart
2015-01-16 wip: tracing signals and adding a ground plane to the mini-pcb with connectors
2015-01-16 adding another ground plane
2015-01-16 exporting mini-pcb to a VRML file
2015-06-23 project directory reorganized
2015-06-23 setting up libraries
2015-06-23 importing common sheets from expression-pedal project
2015-06-23 sch: schematic updated (missing displays circuit)
2015-06-23 README updated
2015-06-24 sch: display circuit done
2015-06-24 sch: MPN added to all components
2015-06-25 sch: fixing VBUS signal and FS1 I/O
2015-06-25 BOM updated
2015-06-25 sch: DRC checked
2015-07-23 sch: added mechanic sheet
2015-07-23 renaming libs to lib
2015-07-23 added keystones to mechanic
2015-07-23 sch: fixing some footprints and MPN
2015-07-23 pcb: importing board dxf files
2015-07-23 sch: kicad libray updated + missing footprints added
2015-07-23 pcb: importing netlist
2015-07-23 sch: channel selector switch is no longer used
2015-07-23 pcb: importing netlist after remove channel selector
2015-07-23 sch: fixing mechanic sheet
2015-07-23 sch: increasing display holes
2015-07-23 pcb: initial placement of footprint with mandatory position
2015-07-24 sch: schematic files reorganized, new sheets for usb and rear board
2015-07-24 pcb: rear board layout done
2016-06-13 fix power voltage
2016-06-13 connecting foot leds directly to cpu
2016-06-13 using now RJ45 connectors without leds
2016-06-13 update 'boards connector' signals
2016-06-13 annotation and ERC
2016-06-13 set RJ45 footprint
2016-06-13 changing footprint of rear board header
2016-06-13 export netlist
2016-06-13 importing netlist
2016-06-13 first placement
2016-06-14 replace reset button by pin header
2016-06-14 importing last sch changes
2016-06-14 initial placement (all footprints)
2016-06-14 update smd caps lib
2016-06-14 fix usb resistors
2016-06-14 several tracks traced
2016-06-14 swapping leds IOs
2016-06-14 two RGB LEDs connected
2016-06-15 all LEDs signals connected
2016-06-15 swapping LCD IOs
2016-06-15 LCD data signals connected
2016-06-15 more IOs swapped
2016-06-15 more LCD signals traced
2016-06-16 swapping IOs
2016-06-16 footswitches signals connected
2016-06-16 lot of tracks connected
2016-06-16 rename 12v line to Vin in the rear board
2016-06-16 all tracks done
2016-06-16 update MPN
2016-06-16 update BOM
2016-06-16 adding missing MPN
2016-06-16 adjust configs
2016-06-16 add gerber files
2016-06-16 add position files
2016-06-17 add board dimensions
2016-07-12 changing one cap PN
2016-07-12 update layout according last RJ45 position
2016-07-12 update gerber/fabrication files
2016-07-15 point the LCD voltage in the MPN
2016-07-15 use footswitch 1 as trigger to firmware upgrade
2016-07-15 remove resistors divider of usb vbus
2016-07-18 use fixed contrast to displays
2016-07-18 DRC done
2016-07-18 update BOM and netlist
2016-07-18 only trigger isp when usb is connected
2016-07-18 update netlist
2016-07-18 lcd contrast comps connected
2016-07-18 increase usb vcc pull down resistor
2016-07-18 update layout adding last sch changes
2017-07-12 sch: fix polarity of lcd backlight mosfets
2017-07-12 sch: replace reset footprint (pin header -> 0402)
2017-07-12 sch: remove 5V regulator
2017-07-12 add graphics symbols library
2017-07-13 sch: control RE pin via uC I/O
2017-07-13 sch: change angled pin header to straight one
2017-07-14 shc: change RE I/O
2017-07-14 pcb: update layout
2017-07-14 sch,pcb: add open hardware symbol
2017-07-14 update gerber files
2018-12-21 update files to KiCAD 5
2018-12-21 decrease res value of display backlight (same footprint); bom updated
2019-03-18 Changed R40 RE from pull-up to pull-down
2019-03-18 Updated gerbers and BOM
2019-04-01 added extra position files as a reference
2019-04-15 updated silk screen
