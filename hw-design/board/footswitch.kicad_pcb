File: hw-design/board/footswitch.kicad_pcb (KiCad board)
At the start: 2 copper layers, 249.4 x 60 mm, 101 parts, among them J1 CC_MAIN, J2 CC_NEXT, P1 FOOT, P2 FOOT, P3 CHAIN, P4 FOOT, P5 FOOT, P6 CONN_01X12, P7 USB_OTG, P8 CONN_01X12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

Commit message: importing last sch changes
Parts:
- removed SW1: SW_PUSH, Buttons_Switches_SMD:SW_SPST_FSMSM
- added P10: CPU_RESET, Pin_Headers:Pin_Header_Straight_1x02, F.Cu at (141.8, 90.0)
- moved Q5 269.9 mm to (85.2, 138.6)
- moved R12 269.9 mm to (90.8, 157.0)
- moved C8 269.9 mm to (81.9, 151.3)
- moved D3 269.9 mm to (91.0, 145.0)
- moved Q2 269.9 mm to (74.2, 156.4)
- moved Q4 269.9 mm to (92.0, 138.1)
- moved R3 269.9 mm to (96.9, 137.8)
- moved R4 269.9 mm to (90.9, 151.1)
- moved R9 269.9 mm to (95.8, 150.3)
- moved C12 210.0 mm to (120.9, 34.3)
- moved P3 210.0 mm to (109.7, 31.6)
- moved P9 210.0 mm to (114.0, 28.2)
- moved C13 210.0 mm to (129.4, 28.3)
- moved Q7 171.4 mm to (194.5, -13.4)
- moved C1 171.4 mm to (187.2, -9.66)
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
Commit message: initial placement (all footprints)
Parts:
- moved C2 183.8 mm to (41.0, 95.9)
- moved C1 181.5 mm to (41.0, 97.9)
- moved Q7 166.2 mm to (73.8, 100.9), turned to 90 degrees
- moved Q1 162.7 mm to (89.5, 98.6)
- moved R19 162.5 mm to (74.1, 98.2)
- moved C3 157.1 mm to (90.7, 103.9)
- moved R8 156.1 mm to (92.6, 99.5), turned to 0 degrees
- moved R5 149.0 mm to (92.6, 97.7), turned to 180 degrees
- moved R35 125.5 mm to (229.6, 96.4)
- moved Q8 121.0 mm to (229.3, 99.1), turned to 90 degrees
- moved C16 110.3 mm to (195.1, 94.4), turned to 180 degrees
- moved C15 109.2 mm to (195.0, 96.7), turned to 180 degrees
- moved Q2 107.8 mm to (163.4, 95.8)
- moved C8 98.2 mm to (160.6, 92.4), turned to 90 degrees
- moved D3 94.4 mm to (172.2, 96.8), turned to 270 degrees
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
Commit message: several tracks traced
Parts:
- P1, P2, P4, P5: moved to F.Cu
- moved C1 30.5 mm to (29.0, 69.8), turned to 90 degrees
- moved C2 28.1 mm to (30.9, 69.6), turned to 90 degrees
- moved P9 20.1 mm to (123.3, 102.2), turned to 270 degrees
- moved C15 19.5 mm to (181.3, 82.8), turned to 90 degrees
- moved C16 16.8 mm to (183.2, 82.6), turned to 90 degrees
- moved C20 16.0 mm to (158.8, 84.8)
- moved C9 13.1 mm to (160.9, 73.9), turned to 180 degrees
- moved R16 12.6 mm to (163.4, 75.7)
- moved Q6 12.5 mm to (164.4, 72.6)
- moved R14 12.3 mm to (167.4, 72.7)
- moved C8 10.1 mm to (168.4, 98.8), turned to 180 degrees
- moved P1 9.77 mm to (69.1, 102.2)
- moved P4 9.65 mm to (75.8, 102.2)
- moved R2 9.07 mm to (216.2, 102.3), turned to 270 degrees
- moved C10 8.96 mm to (191.2, 109.8), turned to 180 degrees
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Connections:
- P6 pad 10: USB_DM -> Net-(P6-Pad10)
- P6 pad 11: USB_DP -> Net-(P6-Pad11)
- R17 pad 1: USB_DM -> Net-(P6-Pad10)
- R17 pad 2: USB_DM_CPU -> USB_DM
- R18 pad 1: USB_DP -> Net-(P6-Pad11)
- R18 pad 2: USB_DP_CPU -> USB_DP
- U3 pad 40: LCD1_BL -> CHAIN_DE
- U3 pad 43: CHAIN_DE -> LCD1_BL
Routing:
- net USB_VCC: track 0.00 -> 35.9 mm, vias 0 -> 1
- net Net-(C10-Pad1): track 0.00 -> 22.6 mm
- net +3V3: track 0.00 -> 21.6 mm
- net Net-(Q2-Pad1): track 0.00 -> 16.7 mm, vias 0 -> 2
- net +12V: track 0.00 -> 16.4 mm, vias 0 -> 2
- net CHAIN_RX: track 0.00 -> 15.1 mm, vias 0 -> 2
- net RESET: track 0.00 -> 14.3 mm, vias 0 -> 2
- net Net-(C8-Pad2): track 0.00 -> 14.1 mm, vias 0 -> 4
- net CHAIN_TX: track 0.00 -> 12.9 mm, vias 0 -> 2
- net Net-(C8-Pad1): track 0.00 -> 12.8 mm, vias 0 -> 2
- net Net-(C5-Pad1): track 0.00 -> 12.5 mm
- net CHAIN_DE: track 0.00 -> 12.1 mm, vias 0 -> 2
- net Net-(C6-Pad1): track 0.00 -> 11.6 mm
- net Net-(C4-Pad1): track 0.00 -> 11.6 mm
- net USB_DP_CPU: track 0.00 -> 10.9 mm
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- added copper zone on F.Cu, net Net-(C10-Pad1)
Other:
- outline, holes or cut-outs redrawn

Commit message: two RGB LEDs connected
Parts:
- moved R1 7.48 mm to (57.4, 105.2)
- moved P9 5.16 mm to (121.3, 107.0)
- moved R10 4.46 mm to (79.2, 105.8)
- moved R2 3.88 mm to (212.9, 104.3)
- moved P1 3.36 mm to (66.8, 104.6)
- moved P2 2.74 mm to (219.2, 104.6)
- moved P4 2.46 mm to (75.8, 104.6)
- moved P8 1.50 mm to (157.3, 104.6)
- moved P5 1.49 mm to (228.2, 104.6)
- moved R11 1.15 mm to (231.0, 103.6)
Connections:
- U3 pad 1: LED_R3 -> LCD_D5
- U3 pad 11: LED_G3 -> LCD_D6
- U3 pad 12: LED_B4 -> LCD_D7
- U3 pad 21: LED_B3 -> LCD_D4
- U3 pad 24: LED_R4 -> LCD1_EN
- U3 pad 30: LCD1_EN -> LED_G4
- U3 pad 31: LED_G4 -> LED_R4
- U3 pad 32: LCD_D7 -> LED_B4
- U3 pad 33: LCD_D6 -> LED_G3
- U3 pad 34: LCD_D5 -> LED_R3
- U3 pad 35: LCD_D4 -> LED_B3
Routing:
- net LED_G4: track 0.00 -> 124.9 mm, vias 0 -> 2
- net LED_B4: track 0.00 -> 123.2 mm, vias 0 -> 2
- net LED_R4: track 0.00 -> 123.0 mm, vias 0 -> 2
- net LED_G3: track 0.00 -> 48.2 mm, vias 0 -> 2
- net LED_R3: track 0.00 -> 47.2 mm, vias 0 -> 2
- net LED_B3: track 0.00 -> 46.9 mm, vias 0 -> 2
- net USB_VCC: track 35.9 -> 6.23 mm, vias 1 -> 0
- net +12V: track 16.4 -> 0.00 mm, vias 2 -> 0
- net USB_DM_CPU: track 10.8 -> 0.00 mm
- net USB_DP_CPU: track 10.9 -> 1.69 mm
- net RESET: track 14.3 -> 7.59 mm, vias 2 -> 0
- net RS485_TX+: track 5.95 -> 0.00 mm
- net RS485_RX+: track 5.83 -> 0.00 mm
- net RS485_TX-: track 5.42 -> 0.00 mm
- net RS485_RX-: track 5.31 -> 0.00 mm
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
Commit message: all LEDs signals connected
Parts:
- moved C3 23.2 mm to (99.9, 125.2)
- moved Q1 23.2 mm to (98.7, 119.8)
- moved R5 23.2 mm to (101.9, 119.0)
- moved R8 23.2 mm to (101.9, 120.7)
Connections:
- U3 pad 13: LED_G1 -> FS4
- U3 pad 16: FS4 -> LED_R2
- U3 pad 17: LCD_RW -> LED_B2
- U3 pad 2: LED_R1 -> Net-(U3-Pad2)
- U3 pad 25: Net-(U3-Pad25) -> LED_B1
- U3 pad 26: LED_B2 -> LED_R1
- U3 pad 27: LCD_CONTRAST -> LED_G1
- U3 pad 38: LED_R2 -> LCD_RW
- U3 pad 48: LED_B1 -> LCD_CONTRAST
Routing:
- net LED_R1: track 0.00 -> 112.5 mm, vias 0 -> 2
- net LED_G1: track 0.00 -> 110.6 mm, vias 0 -> 2
- net LED_B1: track 0.00 -> 110.1 mm, vias 0 -> 2
- net LED_G2: track 0.00 -> 39.8 mm, vias 0 -> 2
- net LED_R2: track 0.00 -> 39.1 mm, vias 0 -> 2
- net LED_B2: track 0.00 -> 37.8 mm, vias 0 -> 2
- net USB_DM_CPU: track 0.00 -> 12.4 mm
- net USB_DP_CPU: track 1.69 -> 12.5 mm
- net LED_B4: track 123.2 -> 125.2 mm
- net LED_G4: track 124.9 -> 123.6 mm

Commit message: LCD data signals connected
Parts:
- moved P3 50.6 mm to (130.6, 128.7)
Connections:
- U3 pad 1: LCD_D5 -> LCD_RS
- U3 pad 10: FS2 -> LCD_D6
- U3 pad 11: LCD_D6 -> LCD_D5
- U3 pad 12: LCD_D7 -> LCD_D4
- U3 pad 21: LCD_D4 -> FS2
- U3 pad 9: LCD_RS -> LCD_D7
Routing:
- net LCD_D5: track 0.00 -> 211.9 mm, vias 0 -> 3
- net LCD_D7: track 0.00 -> 210.5 mm, vias 0 -> 3
- net LCD_D4: track 0.00 -> 208.2 mm, vias 0 -> 3
- net LCD_D6: track 0.00 -> 207.0 mm, vias 0 -> 3
Other:
- board size 249.4 x 60 mm -> 249.4 x 58.5 mm

Commit message: more LCD signals traced
Parts:
- moved C3 103.9 mm to (200.5, 98.8), turned to 180 degrees
- moved Q1 97.6 mm to (193.5, 96.7)
- moved R8 94.9 mm to (194.4, 99.8), turned to 270 degrees
- moved R5 92.8 mm to (192.6, 99.8), turned to 90 degrees
- moved P3 49.9 mm to (149.9, 82.7), turned to 90 degrees
- moved R13 0.77 mm to (128.5, 95.1)
- moved P10 0.53 mm to (147.1, 86.6)
- moved Q7 0.20 mm to (77.3, 97.0)
- moved R19 0.20 mm to (77.6, 94.3)
Connections:
- U3 pad 1: LCD_RS -> FS3
- U3 pad 13: FS4 -> LCD_RW
- U3 pad 15: FS3 -> LCD_RS
- U3 pad 21: FS2 -> LCD1_EN
- U3 pad 23: Net-(U3-Pad23) -> LCD1_BL
- U3 pad 24: LCD1_EN -> Net-(U3-Pad24)
- U3 pad 38: LCD_RW -> FS4
- U3 pad 42: LCD2_EN -> LCD_CONTRAST
- U3 pad 43: LCD1_BL -> FS2
- U3 pad 45: LCD2_BL -> Net-(U3-Pad45)
- U3 pad 46: Net-(U3-Pad46) -> LCD2_BL
- U3 pad 47: Net-(U3-Pad47) -> LCD2_EN
- U3 pad 48: LCD_CONTRAST -> Net-(U3-Pad48)
Routing:
- net LCD_VO: track 0.00 -> 228.2 mm, vias 0 -> 2
- net LCD_RW: track 0.00 -> 212.9 mm, vias 0 -> 3
- net LCD_RS: track 0.00 -> 212.3 mm, vias 0 -> 3
- net LCD1_EN: track 0.00 -> 111.5 mm, vias 0 -> 2
- net LCD2_EN: track 0.00 -> 98.4 mm, vias 0 -> 2
- net LCD2_BL: track 0.00 -> 97.3 mm, vias 0 -> 2
- net LCD1_BL: track 0.00 -> 53.9 mm, vias 0 -> 2
- net LCD_CONTRAST: track 0.00 -> 53.4 mm, vias 0 -> 2
- net Net-(DS2-Pad16): track 0.00 -> 36.5 mm
- net Net-(DS1-Pad16): track 0.00 -> 36.5 mm
- net LCD_D5: track 211.9 -> 215.4 mm
- net Net-(Q1-Pad2): track 0.00 -> 3.14 mm
- net LCD_D6: track 207.0 -> 204.6 mm
- net LCD_D7: track 210.5 -> 208.1 mm
- net LCD_D4: track 208.2 -> 205.8 mm
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