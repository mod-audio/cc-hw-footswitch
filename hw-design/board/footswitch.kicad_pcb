# Repository mod-audio/cc-hw-footswitch

File README.md:

mod-hw-footswitch
=================

This repository contains the schematics and PCB design files for the Footswitch hardware.
This is a peripheral meant to be used in conjunction with MOD (http://moddevices.com/) via its control-chain interface.

These files were created and can be improved with KiCAD, a free software Electronics CAD which is available at http://www.kicad.org/

## Check out instructions ##

This project uses a set of KiCAD symbols and footprints provided by the official KiCad library (https://github.com/KiCad/). In order to properly fetch these dependencies, which are configured as submodule repositories, you have to use the **--recursive** attribute in the following **git** command:

> git clone --recursive https://github.com/portalmod/mod-hw-footswitch.git

## Licensing ##

This is an Open Hardware project and all of the files in this repository are licensed under the terms of the "Creative Commons By-SA" license.

## Firmware ##

The firmware source code is freely available at https://github.com/portalmod/mod-fw-footswitch

## KiCad design hw-design/board/footswitch.kicad_pcb

Parts:
C5: 10uF; c_elec_5x5.3; MPN UWX1E100MCL1GB
C7, C12: 100nF; C_0603; MPN C1608X7R1E104K080AA
C8: 10uF; C_0805; MPN GRM219R61E106KA12D
C10: 100uF; c_elec_6.3x5.3; MPN UWX1C101MCL1GB
D1: CGRA4007-G; Diode-SMA_Standard; MPN CGRA4007-G
D3: 1N5819; SOD-123; MPN 1N5819HW-7-F
Q1, Q4: 2N7002; SOT-23; MPN 2N7002P,215
Q5: FDN306P; SOT-23-fairchild; MPN FDN306P_F095
R3, R4, R8, R13: 10K; R_0603; MPN RMCF0603JT10K0
RT1: PTC_FUSE; R_1210; MPN 0ZCB0050FF2G
U2: NCP1117DT33G; DPAK-2; MPN NCP1117DT33G

Connections:
+3V3: C10.1, C12.1, U2.2 (VO); also elsewhere on the board
+5V: D1.1 (K), D3.1 (K), RT1.1
+12V: D1.2 (A), R3.1; also elsewhere on the board
GNDD: C5.2, C7.2, C10.2, C12.2, Q1.2 (S), Q4.2 (S), R4.2, U2.1 (GND); also elsewhere on the board
unnamed: C5.1, C7.1, RT1.2, U2.3 (VI)
unnamed: C8.1, D3.2 (A), Q5.3 (D)
unnamed: C8.2, Q4.3 (D), Q5.1 (G), R13.2
unnamed: Q1.1 (G), R3.2, R4.1
unnamed: Q1.3 (D), Q4.1 (G), R8.2
USB_VCC: Q5.2 (S), R8.1, R13.1; also elsewhere on the board

Notes on the sheet:
CONTROL CHAIN POWER
USB POWER
+5V power comes from USB and it's activated only if +12V is not present, i.e. when the control chain cable is not plugged in

Parts:
R17, R40: 10K; R_0603; MPN RMCF0603JT10K0
U1: ISL83491; SOIC-14_3.9x8.7mm_Pitch1.27mm; MPN ISL83491IBZ

Connections:
+3V3: U1.13 (VCC), U1.14 (VCC); also elsewhere on the board
CHAIN_DE: R17.2, U1.4 (DE); also elsewhere on the board
CHAIN_RE: R40.1, U1.3 (~RE); also elsewhere on the board
CHAIN_RX: U1.2 (RO); also elsewhere on the board
CHAIN_TX: U1.5 (DI); also elsewhere on the board
GNDD: R17.1, R40.2, U1.6 (GND), U1.7 (GND); also elsewhere on the board
RS485_RX+: U1.12 (A); also elsewhere on the board
RS485_RX-: U1.11 (~B); also elsewhere on the board
RS485_TX+: U1.9 (Y); also elsewhere on the board
RS485_TX-: U1.10 (~Z~); also elsewhere on the board

Notes on the sheet:
INTERFACE

Parts:
C4, C6: 18pF; C_0603; MPN C1608C0G1H180J080AA
C13, C14, C21: 100nF; C_0603; MPN C1608X7R1E104K080AA
P3: CHAIN; Pin_Header_Straight_1x03
P9: SWD; Pin_Header_Straight_2x05_Pitch1.27mm
P10: CPU_RESET; R_0402
R39: 10K; R_0603; MPN RMCF0603JT10K0
U3: LPC11U24FBD48/401; LQFP-48_7x7mm_Pitch0.5mm; MPN LPC11U24FBD48/401
Y1: 12MHz; Crystal_HC49-SD_SMD; MPN FOXSDLF/120-20

Connections:
+3V3: C13.2, C14.2, R39.1, U3.8 (VDD), U3.44 (VDD); also elsewhere on the board
CHAIN_DE: U3.40 (PIO0_16/AD5/CT32B1_MAT3/WAKEUP); also elsewhere on the board
CHAIN_RE: U3.38 (PIO1_22/~RI~/MOSI1); also elsewhere on the board
CHAIN_RX: P3.3, U3.37 (PIO1_14/~DSR~/CT16B0_MAT1/RXD); also elsewhere on the board
CHAIN_TX: P3.2, U3.36 (PIO1_13/~DTR~/CT16B0_MAT0/TXD); also elsewhere on the board
FS1: U3.23 (PIO0_7/~CTS~); also elsewhere on the board
FS2: U3.24 (PIO1_28/CT32B0_CAP0/SCLK); also elsewhere on the board
FS3: U3.45 (PIO0_17/~RTS~/CT32B0_CAP0/SCLK); also elsewhere on the board
FS4: U3.43 (PIO1_15/~DCD~/CT16B0_MAT2/SCK1); also elsewhere on the board
GNDD: C4.2, C6.2, C13.1, C14.1, C21.1, P3.1, P9.3, P9.5, P9.9, P10.2, U3.5 (VSS), U3.41 (VSS); also elsewhere on the board
ISP_TRIGGER: U3.4 (PIO0_1/CLKOUT/CT32B0_MAT2/USB_FTOGGLE); also elsewhere on the board
LCD1_BL: U3.21 (PIO1_24/CT32B0_MAT0); also elsewhere on the board
LCD1_EN: U3.48 (PIO1_16/~RI~/CT16B0_CAP0); also elsewhere on the board
LCD2_BL: U3.46 (PIO0_18/RXD/CT32B0_MAT0); also elsewhere on the board
LCD2_EN: U3.47 (PIO0_19/TXD/CT32B0_MAT1); also elsewhere on the board
LCD_D4: U3.12 (PIO1_27/CT32B0_MAT3/TXD); also elsewhere on the board
LCD_D5: U3.11 (PIO1_26/CT32B0_MAT2/RXD); also elsewhere on the board
LCD_D6: U3.10 (PIO0_2/SSEL0/CT16B0_CAP0); also elsewhere on the board
LCD_D7: U3.9 (PIO0_20/CT16B1_CAP0); also elsewhere on the board
LCD_RS: U3.15 (PIO0_4/SCL); also elsewhere on the board
LCD_RW: U3.13 (PIO1_20/~DSR~/SCK1); also elsewhere on the board
LED_B1: U3.25 (PIO1_31); also elsewhere on the board
LED_B2: U3.17 (PIO0_21/CT16B1_MAT0/MOSI1); also elsewhere on the board
LED_B3: U3.35 (~TRST~/PIO0_14/AD3/CT32B1_MAT1); also elsewhere on the board
LED_B4: U3.32 (TDI/PIO0_11/AD0/CT32B0_MAT3); also elsewhere on the board
LED_G1: U3.27 (PIO0_8/MISO0/CT16B0_MAT0); also elsewhere on the board
LED_G2: U3.18 (PIO1_23/CT16B1_MAT1/SSEL1); also elsewhere on the board
LED_G3: U3.33 (TMS/PIO0_12/AD1/CT32B1_CAP0); also elsewhere on the board
LED_G4: U3.30 (PIO0_22/AD6/CT16B1_MAT1/MISO1); also elsewhere on the board
LED_R1: U3.26 (PIO1_21/~DCD~/MISO1); also elsewhere on the board
LED_R2: U3.16 (PIO0_5/SDA); also elsewhere on the board
LED_R3: U3.34 (TDO/PIO0_13/AD2/CT32B1_MAT0); also elsewhere on the board
LED_R4: U3.31 (PIO1_29/SCK0/CT32B0_CAP1); also elsewhere on the board
unnamed: C4.1, U3.6 (XTALIN), Y1.1
unnamed: C6.1, U3.7 (XTALOUT), Y1.2
RESET: C21.2, P9.10, P10.1, R39.2, U3.3 (~RESET~/PIO0_0)
SWCLK: P9.4, U3.29 (SWCLK/PIO0_10/SCK0/CT16B0_MAT2)
SWDIO: P9.2, U3.39 (SWDIO/PIO0_15/AD4/CT32B1_MAT2)
SWO: P9.6, U3.28 (PIO0_9/MOSI0/CT16B0_MAT1)
USB_CONNECT: U3.22 (PIO0_6/~USB_CONNECT~/SCK0); also elsewhere on the board
USB_DM_CPU: U3.19 (USB_DM); also elsewhere on the board
USB_DP_CPU: U3.20 (USB_DP); also elsewhere on the board
USB_VBUS: U3.14 (PIO0_3/USB_VBUS); also elsewhere on the board

Notes on the sheet:
SWD
RESET

Parts:
D5, D6, D7, D8: LED_RGB; LED-RGB_PLLC-6; MPN LTRBGFSF-ABCB-QKYO-Z
P1, P2, P4, P5: FOOT; Pin_Header_Angled_1x02; MPN M20-9960245
R1, R2, R11, R12: 10K; R_0603; MPN RMCF0603JT10K0
R23, R24, R25, R28, R29, R30, R31, R32, R33, R34, R35, R36: 220R; R_0603; MPN RMCF0603JT220R

Connections:
+3V3: D5.4 (BA), D5.5 (GA), D5.6 (RA), D6.4 (BA), D6.5 (GA), D6.6 (RA), D7.4 (BA), D7.5 (GA), D7.6 (RA), D8.4 (BA), D8.5 (GA), D8.6 (RA), R1.1, R2.1, R11.1, R12.1; also elsewhere on the board
FS1: P1.1, R1.2; also elsewhere on the board
FS2: P4.1, R11.2; also elsewhere on the board
FS3: P2.1, R2.2; also elsewhere on the board
FS4: P5.1, R12.2; also elsewhere on the board
GNDD: P1.2, P2.2, P4.2, P5.2; also elsewhere on the board
LED_B1: R23.1; also elsewhere on the board
LED_B2: R28.1; also elsewhere on the board
LED_B3: R31.1; also elsewhere on the board
LED_B4: R34.1; also elsewhere on the board
LED_G1: R25.1; also elsewhere on the board
LED_G2: R30.1; also elsewhere on the board
LED_G3: R33.1; also elsewhere on the board
LED_G4: R36.1; also elsewhere on the board
LED_R1: R24.1; also elsewhere on the board
LED_R2: R29.1; also elsewhere on the board
LED_R3: R32.1; also elsewhere on the board
LED_R4: R35.1; also elsewhere on the board
unnamed: D5.1 (RC), R23.2
unnamed: D5.2 (GC), R24.2
unnamed: D5.3 (BC), R25.2
unnamed: D6.1 (RC), R28.2
unnamed: D6.2 (GC), R29.2
unnamed: D6.3 (BC), R30.2
unnamed: D7.1 (RC), R31.2
unnamed: D7.2 (GC), R32.2
unnamed: D7.3 (BC), R33.2
unnamed: D8.1 (RC), R34.2
unnamed: D8.2 (GC), R35.2
unnamed: D8.3 (BC), R36.2

Notes on the sheet:
FOOTSWITCHES
LEDs

Parts:
C1, C15: 100nF; C_0603; MPN C1608X7R1E104K080AA
C2, C16: 10uF; C_0805; MPN GRM219R61E106KA12D
C3, C17: 1uF; C_0805; MPN C2012X7R1E105K125AB
DS1, DS2: ERM1602FS-6 3.3V; WC1602A; MPN ERM1602FS-6 3.3V
Q7, Q8: 2N7002; SOT-23; MPN 2N7002P,215
R9, R21: 2K4; R_0603
R15, R22: 1.2K; R_0603; MPN RMCF0603JT1K20
R19, R38: 100K; R_0603; MPN RMCF0603JT100K

Connections:
+3V3: C1.1, C2.1, C15.1, C16.1, DS1.2 (VDD), DS1.15 (LED+), DS2.2 (VDD), DS2.15 (LED+), R9.2, R19.1, R21.2, R38.1; also elsewhere on the board
GNDD: C1.2, C2.2, C3.2, C15.2, C16.2, C17.2, DS1.1 (VSS), DS1.7 (DB0), DS1.8 (DB1), DS1.9 (DB2), DS1.10 (DB3), DS2.1 (VSS), DS2.7 (DB0), DS2.8 (DB1), DS2.9 (DB2), DS2.10 (DB3), Q7.2 (S), Q8.2 (S), R15.2, R22.2; also elsewhere on the board
LCD1_BL: Q7.1 (G); also elsewhere on the board
LCD1_EN: DS1.6 (E); also elsewhere on the board
LCD2_BL: Q8.1 (G); also elsewhere on the board
LCD2_EN: DS2.6 (E); also elsewhere on the board
LCD_D4: DS1.11 (DB4), DS2.11 (DB4); also elsewhere on the board
LCD_D5: DS1.12 (DB5), DS2.12 (DB5); also elsewhere on the board
LCD_D6: DS1.13 (DB6), DS2.13 (DB6); also elsewhere on the board
LCD_D7: DS1.14 (DB7), DS2.14 (DB7); also elsewhere on the board
LCD_RS: DS1.4 (RS), DS2.4 (RS); also elsewhere on the board
LCD_RW: DS1.5 (R/~W), DS2.5 (R/~W); also elsewhere on the board
unnamed: C3.1, DS1.3 (Vo), R9.1, R15.1
unnamed: C17.1, DS2.3 (Vo), R21.1, R22.1
unnamed: DS1.16 (LED-), Q7.3 (D), R19.2
unnamed: DS2.16 (LED-), Q8.3 (D), R38.2

Parts:
H1, H2, H3, H4, H5, H6: HOLE; M3-screw-hole
H7, H8: KEYSTONE; Keystone-7790; MPN Keystone 7790

Notes on the sheet:
BOARD STANDOFF
KEYSTONE HOLES

Parts:
C9: 100nF; C_0603; MPN C1608X7R1E104K080AA
C19: 10nF 500V; C_1206; MPN 501R18W103KV4E
D2: 1N4148; SOD-323; MPN 1N4148WX-TP
J1: CC_MAIN; 54602-908LF; MPN 54602-908LF
J2: CC_NEXT; 54602-908LF; MPN 54602-908LF
P6: CONN_01X12; Pin_Header_Straight_1x12; MPN 68016-112HLF
P7: USB_OTG; USB_Mini-B; MPN 10033526-N3212LF
P8: CONN_01X12; Pin_Header_Angled_1x12; MPN 68016-112HLF
Q6: IRFML8244TRPBF; SOT-23; MPN IRFML8244TRPBF
R16: 100R; R_0805; MPN ERJ-P06F1000V
R18: 10K; R_0603; MPN RMCF0603JT10K0
R26, R27: 33R; R_0603; MPN MCR03ERTF33R0
R37: 1M; R_0603; MPN RMCF0603JT1M00

Connections:
+12V: P8.1, P8.2; also elsewhere on the board
CC_OUTPUT_DET: C9.1, D2.2 (A), Q6.1 (G), R18.2
GNDD: C9.2, C19.2, J1.7, J1.8, J2.8, P6.5, P6.8, P6.12, P7.5 (GND), P8.5, P8.8, P8.12, R37.1; also elsewhere on the board
unnamed: C19.1, P7.6 (shield), R37.2
unnamed: D2.1 (K), J2.7
unnamed: P6.10, R26.1
unnamed: P6.11, R27.1
unnamed: Q6.2 (S), R16.1
RJ45_RX+: J1.1, J2.1, P6.3, R16.2
RJ45_RX-: J1.2, J2.2, P6.4, Q6.3 (D)
RJ45_TX+: J1.3, J2.3, P6.7
RJ45_TX-: J1.6, J2.6, P6.6
RS485_RX+: P8.3; also elsewhere on the board
RS485_RX-: P8.4; also elsewhere on the board
RS485_TX+: P8.7; also elsewhere on the board
RS485_TX-: P8.6; also elsewhere on the board
USB_DM: P7.2 (D-), R26.2
USB_DM_CPU: P8.10; also elsewhere on the board
USB_DP: P7.3 (D+), R27.2
USB_DP_CPU: P8.11; also elsewhere on the board
USB_PLUG_VCC: P6.9, P7.1 (VCC)
USB_VCC: P8.9; also elsewhere on the board
VIN: J1.4, J1.5, J2.4, J2.5, P6.1, P6.2, R18.1

Notes on the sheet:
CONTROL CHAIN
USB
TERMINATION RESISTOR
BOARDS CONNECTORS

Parts:
C11: 100nF; C_0603; MPN C1608X7R1E104K080AA
Q2: BC857; SOT-23; MPN BC857B,215
Q3: 2N7002; SOT-23; MPN 2N7002P,215
R5: 3K; R_0603; MPN MCR03ERTF3001
R6: 100K; R_0603; MPN RMCF0603JT100K
R7: 24K; R_0603; MPN MCR03ERTF2402
R10: 10K; R_0603; MPN RMCF0603JT10K0
R14: 1K5; R_0603; MPN MCR03ERTF1501
R20: 100R; R_0603; MPN RMCF0603JT100R

Connections:
+3V3: Q2.2 (E), R7.2, R10.2; also elsewhere on the board
FS1: Q3.2 (S); also elsewhere on the board
GNDD: C11.2, R6.1; also elsewhere on the board
ISP_TRIGGER: Q3.3 (D), R10.1; also elsewhere on the board
unnamed: Q2.1 (B), R5.2, R7.1
unnamed: Q2.3 (C), R14.2
USB_CONNECT: R5.1; also elsewhere on the board
USB_DP_CPU: R14.1; also elsewhere on the board
USB_VBUS: R20.1; also elsewhere on the board
USB_VCC: C11.1, Q3.1 (G), R6.2, R20.2; also elsewhere on the board

Notes on the sheet:
USB DEVICE

Board: 2 copper layers, 249.4 x 58.5 mm, 102 parts (4 on the bottom side), 87 nets.

Other parts of the board:
LOGO1: Logo_Open_Hardware_Small; OSHW-Logo2_9.8x8mm_SilkScreen

## KiCad design hw-design/footswitch.kicad_pcb

Board: 2 copper layers, 68.6 x 19.6 mm, 5 parts (0 on the bottom side), 16 nets.

Parts:
CN1, CN2: CONN_PANNEL_2X2; CONN_PANNEL
J1: RJ45_CHAIN_MAIN; RJ45-RJHSE5084
J2: RJ45_CHAIN_EXTENSION; RJ45-RJHSE5084
P3: CONN_8X2; pin_array_8x2

Connections:
P3_DGND: CN1.1, CN2.1, J1.11, P3.15
P3_EXT_LED1A: J2.9, P3.14
P3_EXT_LED1C: J2.10, P3.12
P3_EXT_LED2A: J2.11, P3.10
P3_EXT_LOAD: J2.8, P3.16
P3_GND_FB: J2.7, P3.11
P3_MAIN_LED1A: J1.9, P3.8
P3_MAIN_LED1C: J1.10, P3.6
P3_MAIN_LED2C: J1.12, P3.4
P3_MAIN_LOAD: J1.7, J1.8, P3.13
P3_RS422_RX+: J1.3, J2.1, P3.5
P3_RS422_RX-: J1.6, J2.2, P3.7
P3_RS422_TX+: J1.1, J2.3, P3.1
P3_RS422_TX-: J1.2, J2.6, P3.3
P3_VCC: J1.4, J2.4, J2.5, J2.12, P3.2
P3_VCC_FB: J1.5, P3.9

## KiCad design MOD_Foot_Prototype1/MOD_Foot_Prototype1.kicad_pcb

Schematic: control-chain.sch, MOD Footswitch Extensor

Parts:
C5: 100uF; CAP_RAD_5MM
C8, C18: 100nF_X7R; SM0603
D2, D3: MMSZ5242B; SOD123
J1: RJ45_CHAIN_MAIN; RJ45-RJHSE5084
J2: RJ45_CHAIN_EXTENSION; RJ45-RJHSE5084
Q1: MMBT3904; SOT23
Q2: MMBT3906; SOT23
R1, R27: 1k; SM0603
R2, R11: 100R 0.5W; SM1210
R3, R4, R5, R6: 470R; SM0805
R12, R13, R28, R29, R30, R31: 10k; SM0603
R44: 0R/NC; SM0805
U4: MAX13450E; TSSOP14

Connections:
+3.3V: R3.1, R4.1, R5.1, R6.1; also elsewhere on the board
+5V: Q2.2, R13.1, R29.1, R30.1, U4.4; also elsewhere on the board
LED5: R1.1; also elsewhere on the board
unnamed: C5.1, C8.1, J2.7, R12.1
unnamed: C18.1, U4.6
unnamed: J1.7, J1.8, R2.1
unnamed: J1.9 (LED1A), J2.9 (LED1A), Q1.3 (C)
unnamed: J1.10 (LED1C), R5.2
unnamed: J1.12 (LED2C), R6.2
unnamed: J2.8, R11.1
unnamed: J2.10 (LED1C), R3.2
unnamed: J2.12 (LED2C), R4.2
unnamed: Q2.1, R27.2
unnamed: R12.2, R13.2, R27.1
unnamed: R30.2, R44.2, U4.13
RS485_RX+: D2.2 (K), J1.3, J2.1, U4.8
RS485_RX-: D3.2 (K), J1.6, J2.2, U4.9
RS485_TX+: J1.1, J2.3, U4.10
RS485_TX-: J1.2, J2.6, U4.12
RTERM_CHAIN: Q2.3, R28.1, U4.5
RX_CHAIN: R29.2, U4.7; also elsewhere on the board
TX_CHAIN: U4.3; also elsewhere on the board
TX_CHAIN_EN: R31.1, U4.1; also elsewhere on the board
VCC: J1.4, J1.5, J2.4, J2.5; also elsewhere on the board

Notes on the sheet:
PCB consideration: This capacitor must be placed as close as possible to the IC

Notices in the files:
MOD_Foot_Prototype1/MOD_Foot_Prototype1.kicad_pcb:
(c) 2014 Musical Operating Devices
Licensed under CC By-SA
